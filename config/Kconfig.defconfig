## config/Kconfig.defconfig
```kconfig
config I2C
	default y

config SSD1306
	default y

config SSD1306_REVERSE_MODE
	default y
```
